# Keil uVision project STemWin.uvprojx, settings and files
target STemWin (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STemWin +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\STemWin\Config;..\STemWin\inc;..\STemWin\Lib;..\STemWin\OS;..\rt-thread-3.1.3\bsp;..\rt-thread-3.1.3\include;..\rt-thread-3.1.3\include\libc;..\rt-thread-3.1.3\components;..\rt-thread-3.1.3\libcpu\arm\cortex-m3;..\rt-thread-3.1.3\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User
    ../Src/: mylcd.c malloc.c main.c gpio.c crc.c fsmc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f103xe.s
    ../Src/: system_stm32f1xx.c
  group STemwin_Config
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../STemWin/OS/: GUI_X.c
  group STemwin_Lib
    ../STemWin/Lib/: STemWin526_CM3_Keil.lib
  group RT-Thread_libcpu
    ../rt-thread-3.1.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group RT-Thread_os
    ../rt-thread-3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread_bsp
    ../rt-thread-3.1.3/bsp/: board.c
software components: CMSIS:CORE 4.3.0
